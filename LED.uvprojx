# Keil uVision project LED.uvprojx, settings and files
target Target 1 (5060750::V5.06 update 6 (build 750)::ARMCC)
  device: S32K144HAxxxLLx NXP
  pack: Keil.S32_SDK_DFP.1.5.0
  cpu: IRAM(0x20000000,0x00007000) IRAM2(0x1FFF8000,0x00008000) IROM(0x00000000,0x00080000) CPUTYPE("Cortex-M4") FPU2 CLOCK(12000000) ELITTLE
  output: LED
  c flags: Optim=1 OneElfS=1 uC99=1 uGnu=1 v6Lang=1 v6LangP=1 wLevel=2
  c define: CPU_S32K144HFT0VLLT,ENABLE_FPU,_DLIB_FILE_DESCRIPTOR
  c include: .\include
  memory RVCT4: ROM 0x0 size 0x80000
  memory RVCT9: RAM 0x20000000 size 0x7000
  memory RVCT10: RAM 0x1fff8000 size 0x8000
  scatter file: .\Linker\S32K144_64_flash.sct
  group STARTUP
    ./startup/: startup_S32K144.s
  group src
    ./src/: clocks_and_modes.c main.c
  group inc
    ./include/: clocks_and_modes.h devassert.h device_registers.h LPUART.h s32_core_cm4.h S32K144.h S32K144_features.h startup.h system_S32K144.h
software components: CMSIS:CORE 5.1.1, Device:Startup 2.0.0
